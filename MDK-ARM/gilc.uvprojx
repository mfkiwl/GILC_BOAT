# Keil uVision project gilc.uvprojx, settings and files
target gilc_lib (6100001::V6.10.1::.\ARMCompiler6.10.1)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: libgilcvehicle_stm32h7 +hex (library)
  c flags: Optim=7 OneElfS=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,STM32
  c misc: -Wno-writable-strings  -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\src\common;..\src\configure;..\src\gilc;..\src\gnss;..\src\inc;..\src\math;..\src\protocol;..\src
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group gilc
    ../src/gilc/: Comfunc.cpp CSINS.cpp GILC.h GILC_Config.h GILC_IOFile.cpp GILC_IOFile.h GILC_KF.cpp GILC_KF.h GILC_Vehicle_lib.cpp
  group common
    ../src/common/: buffer.c buffer.h hc_type.h log.cpp log.h mem.c mem.h malloc_allocator.h
  group math
    ../src/math/: filter.cpp filter.h
software components: Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.4.0
